#include "gfx.h"
#include <math.h>
#include <stdint.h>
#include <stdlib.h>
#include <string.h>
#define WIDTH 128
#define HEIGHT 64

static const uint8_t ascii_font[128][7] = {
    [' '] = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    ['0'] = {0x1F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F},
    ['1'] = {0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04},
    ['2'] = {0x1F, 0x01, 0x01, 0x1F, 0x10, 0x10, 0x1F},
    ['3'] = {0x1F, 0x01, 0x01, 0x1F, 0x01, 0x01, 0x1F},
    ['4'] = {0x11, 0x11, 0x11, 0x1F, 0x01, 0x01, 0x01},
    ['5'] = {0x1F, 0x10, 0x10, 0x1F, 0x01, 0x01, 0x1F},
    ['6'] = {0x1F, 0x10, 0x10, 0x1F, 0x11, 0x11, 0x1F},
    ['7'] = {0x1F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01},
    ['8'] = {0x1F, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x1F},
    ['9'] = {0x1F, 0x11, 0x11, 0x1F, 0x01, 0x01, 0x1F},
    [':'] = {0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00},
    ['A'] = {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11},
    ['B'] = {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E},
    ['C'] = {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E},
    ['D'] = {0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E},
    ['E'] = {0x1F, 0x10, 0x10, 0x1F, 0x10, 0x10, 0x1F},
    ['F'] = {0x1F, 0x10, 0x10, 0x1F, 0x10, 0x10, 0x10},
    ['G'] = {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0E},
    ['H'] = {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11},
    ['I'] = {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E},
    ['J'] = {0x06, 0x02, 0x02, 0x02, 0x12, 0x12, 0x0C},
    ['K'] = {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11},
    ['L'] = {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F},
    ['M'] = {0x11, 0x1B, 0x15, 0x11, 0x11, 0x11, 0x11},
    ['N'] = {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11},
    ['O'] = {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
    ['P'] = {0x1F, 0x11, 0x11, 0x1F, 0x10, 0x10, 0x10},
    ['Q'] = {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D},
    ['R'] = {0x1F, 0x11, 0x11, 0x1F, 0x14, 0x12, 0x11},
    ['S'] = {0x0E, 0x11, 0x10, 0x0E, 0x01, 0x11, 0x0E},
    ['T'] = {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04},
    ['U'] = {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
    ['V'] = {0x11, 0x11, 0x11, 0x11, 0x0A, 0x0A, 0x04},
    ['W'] = {0x11, 0x11, 0x11, 0x11, 0x15, 0x1B, 0x11},
    ['X'] = {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11},
    ['Y'] = {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04},
    ['Z'] = {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}};

void gfx_draw_pixel(uint8_t *fb, int x, int y) {
  if (x < 0 || x >= WIDTH || y < 0 || y >= HEIGHT)
    return;
  int page = y / 8;
  int idx = x + page * WIDTH;
  int bit = y % 8;
  fb[idx] |= (1 << bit);
}

void gfx_draw_rect(uint8_t *fb, int x1, int y1, int x2, int y2) {
  for (int i = x1; i <= x2; i++)
    for (int j = y1; j <= y2; j++)
      gfx_draw_pixel(fb, i, j);
}

void gfx_clear(uint8_t *fb) { memset(fb, 0x00, WIDTH * HEIGHT / 8); }

void gfx_draw_font(uint8_t *fb, int x, int y, int ch, int scale) {
  int w = 5;
  int h = 7;
  for (int i = y; i < y + h; i++)
    for (int j = x; j < x + w; j++)
      if (ascii_font[ch][i - y] & (1 << (w + (x - j) - 1)))
        gfx_draw_rect(fb, x + (j - x) * scale, y + (i - y) * scale,
                      x + (j - x) * scale + scale - 1,
                      y + (i - y) * scale + scale - 1);
}

void gfx_print(uint8_t *fb, int x, int y, char str[], uint8_t scale,
               uint8_t space) {
  int i = 0;
  int w = 5;
  while (str[i] != '\0') {
    gfx_draw_font(fb, x, y, (int)str[i], scale);
    x += w * scale + space;
    i++;
  }
}

void gfx_draw_line(uint8_t *fb, int x1, int y1, int x2, int y2) {
  // Horizontal line
  if (y1 == y2) {
    int sx = (x2 >= x1) ? 1 : -1;
    for (int x = x1;; x += sx) {
      gfx_draw_pixel(fb, x, y1);
      if (x == x2)
        break;
    }
    return;
  }
  // Vertical line
  if (x1 == x2) {
    int sy = (y2 >= y1) ? 1 : -1;
    for (int y = y1;; y += sy) {
      gfx_draw_pixel(fb, x1, y);
      if (y == y2)
        break;
    }
    return;
  }
  int dx = abs(x2 - x1);
  int dy = abs(y2 - y1);
  if (dy > dx)
    return;
  int sx = (x2 >= x1) ? 1 : -1;
  int sy = (y2 >= y1) ? 1 : -1;
  int err = dx / 2;
  int x = x1;
  int y = y1;
  while (1) {
    gfx_draw_pixel(fb, x, y);
    if (x == x2)
      break;
    err += dy;
    if (err >= dx) {
      err -= dx;
      y += sy;
    }
    x += sx;
  }
}
